# IAR project OS2.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405VG ST STM32F405VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; USE_STM324xG_EVAL; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\User\APP; ..\User\BSP; ..\User\BSP\ST\CMSIS\Include; ..\User\BSP\ST\STM32F4xx_StdPeriph_Driver\inc; ..\System\uC-CPU; ..\System\uC-LIB; ..\System\uC-CPU; ..\System\uCOS-II\Ports\ARM-Cortex-M4\Generic\IAR; ..\System\uCOS-II\Source; ..\Drivers\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OS2.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\User\BSP\IAR\stm32f405xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ../User/APP/: app.c console.c stm32f4xx_it.c
  group BSP
    ../User/BSP/: bsp.c bsp_periph.c
    ../User/BSP/ST/CMSIS/: system_stm32f4xx.c
  group BSP/IAR
    ../User/BSP/IAR/: startup_stm32f40xx.s
  group BSP/STM32F4xx_StdPeriph_Driver
    ../User/BSP/ST/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Drivers
    ../Drivers/src/: ch378.c drivers.c serial.c Uart.c
  group uC/CPU
    ../System/uC-CPU/: cpu_a.asm cpu_c.c cpu_core.c
  group uC/LIB
    ../System/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/LIB/Ports/ARM-Cortex-M4/IAR
    ../System/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group uC/OS-II/Ports/ARM-Cortex-M4/Generic/IAR
    ../System/uCOS-II/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II/Source
    ../System/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
